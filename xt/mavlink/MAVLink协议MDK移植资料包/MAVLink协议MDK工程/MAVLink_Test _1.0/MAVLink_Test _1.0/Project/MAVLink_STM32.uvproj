# Keil uVision project MAVLink_STM32.uvproj, settings and files
target MAVLink_STM32 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MAVLink_STM32 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c misc: --c99 --no_strict --gnu
  c include: ..\Codes\User;..\Codes\MAVLink;..\Codes\MAVLink\common;..\Codes\Driver;..\Codes\FWlib;..\Codes\FWlib\src;..\Codes\FWlib\inc;..\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Codes/CMSIS/startup/: startup_stm32f10x_md.s
  group User
    ../Codes/User/: main.c
  group MAVLink
    ../Codes/MAVLink/common/: common.h mavlink.h mavlink_msg_attitude.h mavlink_msg_attitude_quaternion.h mavlink_msg_attitude_setpoint_external.h mavlink_msg_auth_key.h mavlink_msg_battery_status.h mavlink_msg_change_operator_control.h mavlink_msg_change_operator_control_ack.h mavlink_msg_command_ack.h mavlink_msg_command_long.h mavlink_msg_data_stream.h mavlink_msg_data_transmission_handshake.h mavlink_msg_debug.h mavlink_msg_debug_vect.h mavlink_msg_distance_sensor.h mavlink_msg_encapsulated_data.h mavlink_msg_file_transfer_dir_list.h mavlink_msg_file_transfer_res.h mavlink_msg_file_transfer_start.h mavlink_msg_global_position_int.h mavlink_msg_global_position_setpoint_external_int.h mavlink_msg_global_position_setpoint_int.h mavlink_msg_global_vision_position_estimate.h mavlink_msg_gps_global_origin.h mavlink_msg_gps_inject_data.h mavlink_msg_gps_raw_int.h mavlink_msg_gps_rtk.h mavlink_msg_gps_status.h mavlink_msg_gps2_raw.h mavlink_msg_gps2_rtk.h mavlink_msg_heartbeat.h mavlink_msg_highres_imu.h mavlink_msg_hil_controls.h mavlink_msg_hil_gps.h mavlink_msg_hil_optical_flow.h mavlink_msg_hil_rc_inputs_raw.h mavlink_msg_hil_sensor.h mavlink_msg_hil_state.h mavlink_msg_hil_state_quaternion.h mavlink_msg_local_ned_position_setpoint_external.h mavlink_msg_local_position_ned.h mavlink_msg_local_position_ned_system_global_offset.h mavlink_msg_local_position_setpoint.h mavlink_msg_log_data.h mavlink_msg_log_entry.h mavlink_msg_log_erase.h mavlink_msg_log_request_data.h mavlink_msg_log_request_end.h mavlink_msg_log_request_list.h mavlink_msg_manual_control.h mavlink_msg_manual_setpoint.h mavlink_msg_memory_vect.h mavlink_msg_mission_ack.h mavlink_msg_mission_clear_all.h mavlink_msg_mission_count.h mavlink_msg_mission_current.h mavlink_msg_mission_item.h mavlink_msg_mission_item_reached.h mavlink_msg_mission_request.h mavlink_msg_mission_request_list.h mavlink_msg_mission_request_partial_list.h mavlink_msg_mission_set_current.h mavlink_msg_mission_write_partial_list.h mavlink_msg_named_value_float.h mavlink_msg_named_value_int.h mavlink_msg_nav_controller_output.h mavlink_msg_omnidirectional_flow.h mavlink_msg_optical_flow.h mavlink_msg_param_request_list.h mavlink_msg_param_request_read.h mavlink_msg_param_set.h mavlink_msg_param_value.h mavlink_msg_ping.h mavlink_msg_power_status.h mavlink_msg_radio_status.h mavlink_msg_raw_imu.h mavlink_msg_raw_pressure.h mavlink_msg_rc_channels.h mavlink_msg_rc_channels_override.h mavlink_msg_rc_channels_raw.h mavlink_msg_rc_channels_scaled.h mavlink_msg_request_data_stream.h mavlink_msg_roll_pitch_yaw_rates_thrust_setpoint.h mavlink_msg_roll_pitch_yaw_speed_thrust_setpoint.h mavlink_msg_roll_pitch_yaw_thrust_setpoint.h mavlink_msg_safety_allowed_area.h mavlink_msg_safety_set_allowed_area.h mavlink_msg_scaled_imu.h mavlink_msg_scaled_imu2.h mavlink_msg_scaled_pressure.h mavlink_msg_serial_control.h mavlink_msg_servo_output_raw.h mavlink_msg_set_global_position_setpoint_int.h mavlink_msg_set_gps_global_origin.h mavlink_msg_set_local_position_setpoint.h mavlink_msg_set_mode.h mavlink_msg_set_quad_motors_setpoint.h mavlink_msg_set_quad_swarm_led_roll_pitch_yaw_thrust.h mavlink_msg_set_quad_swarm_roll_pitch_yaw_thrust.h mavlink_msg_set_roll_pitch_yaw_speed_thrust.h mavlink_msg_set_roll_pitch_yaw_thrust.h mavlink_msg_setpoint_6dof.h mavlink_msg_setpoint_8dof.h mavlink_msg_sim_state.h mavlink_msg_state_correction.h mavlink_msg_statustext.h mavlink_msg_sys_status.h mavlink_msg_system_time.h mavlink_msg_terrain_check.h mavlink_msg_terrain_data.h mavlink_msg_terrain_report.h mavlink_msg_terrain_request.h mavlink_msg_vfr_hud.h mavlink_msg_vicon_position_estimate.h mavlink_msg_vision_position_estimate.h mavlink_msg_vision_speed_estimate.h testsuite.h version.h
    ../Codes/MAVLink/: checksum.h mavlink_conversions.h mavlink_helpers.h mavlink_types.h protocol.h mavlink_bridge_header.h
  group Driver
    ../Codes/Driver/: gpio_conf.h ANO_Drv_Usart1.c ANO_Drv_Usart1.h
  group FWlib
    ../Codes/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../Codes/CMSIS/: core_cm3.c system_stm32f10x.c
